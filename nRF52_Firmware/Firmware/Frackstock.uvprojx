# Keil uVision project Frackstock.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Frackstock +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52 BOARD_CUSTOM NFC_NDEF_LAUNCHAPP_MSG=1 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT NRF52 NRF52832_XXAA NRF52_PAN_74 SWI_DISABLE0 NRF_LOG
  c include: ./inc;../nRF5_SDK_14.2.0_17b948a/components/libraries/util;../nRF5_SDK_14.2.0_17b948a/components/softdevice/s132/headers;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/hal;../nRF5_SDK_14.2.0_17b948a/components/device;../nRF5_SDK_14.2.0_17b948a/components/toolchain/cmsis/include;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/pwm;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/spi_slave;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/delay;../nRF5_SDK_14.2.0_17b948a/components/toolchain;../nRF5_SDK_14.2.0_17b948a/components/libraries/pwm;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/timer;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/common;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/ppi;../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log;../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_section_vars;../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log/src;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/gpiote;../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_memobj;../nRF5_SDK_14.2.0_17b948a/components/libraries/balloc;../nRF5_SDK_14.2.0_17b948a/components/libraries/atomic;../nRF5_SDK_14.2.0_17b948a/components/libraries/strerror;../nRF5_SDK_14.2.0_17b948a/components/nfc/t2t_lib;../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/launchapp;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/twi_master;../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/generic/message;../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/generic/record;../nRF5_SDK_14.2.0_17b948a/components/boards;../nRF5_SDK_14.2.0_17b948a/components/nfc/t2t_lib/hal_t2t;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/clock;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/saadc;../nRF5_SDK_14.2.0_17b948a/components/ble/common;../nRF5_SDK_14.2.0_17b948a/components/ble/ble_advertising;../nRF5_SDK_14.2.0_17b948a/components/ble/nrf_ble_gatt;../nRF5_SDK_14.2.0_17b948a/components/ble/ble_services/ble_nus;../nRF5_SDK_14.2.0_17b948a/components/softdevice/common;../nRF5_SDK_14.2.0_17b948a/components/libraries/fstorage;../nRF5_SDK_14.2.0_17b948a/components/libraries/timer;../nRF5_SDK_14.2.0_17b948a/components/libraries/bsp;../nRF5_SDK_14.2.0_17b948a/components/libraries/button;../nRF5_SDK_14.2.0_17b948a/components/libraries/scheduler;../nRF5_SDK_14.2.0_17b948a/components/libraries/fifo;../nRF5_SDK_14.2.0_17b948a/components/libraries/pwr_mgmt;../nRF5_SDK_14.2.0_17b948a/components/libraries/atomic_fifo;../nRF5_SDK_14.2.0_17b948a/components/libraries/mutex;../nRF5_SDK_14.2.0_17b948a/components/libraries/atomic_fifo;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/uart;../nRF5_SDK_14.2.0_17b948a/external/segger_rtt;../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log;../nRF5_SDK_14.2.0_17b948a/components/libraries/cli;../nRF5_SDK_14.2.0_17b948a/external/fprintf;../nRF5_SDK_14.2.0_17b948a/components/libraries/queue;../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/i2s
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  group Source Group 1
    ./src/: main.c leds.c nfc.c lis3de.c bluetooth.c stns01.c patterncontrol.c boardsupport.c
    ./inc/: sdk_config.h custom_board.h
  group SDK
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/pwm/: app_pwm.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/pwm/: nrf_drv_pwm.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c sdk_mapped_flags.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_memobj/: nrf_memobj.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/strerror/: nrf_strerror.c
    ../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/launchapp/: nfc_launchapp_rec.c nfc_launchapp_msg.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../nRF5_SDK_14.2.0_17b948a/components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../nRF5_SDK_14.2.0_17b948a/components/nfc/t2t_lib/: nfc_t2t_lib_keil.lib
    ../nRF5_SDK_14.2.0_17b948a/components/nfc/t2t_lib/hal_t2t/: hal_nfc_t2t.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/hal/: nrf_saadc.c
    ../nRF5_SDK_14.2.0_17b948a/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c ble_conn_state.c
    ../nRF5_SDK_14.2.0_17b948a/components/ble/ble_advertising/: ble_advertising.c
    ../nRF5_SDK_14.2.0_17b948a/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../nRF5_SDK_14.2.0_17b948a/components/ble/ble_services/ble_nus/: ble_nus.c
    ../nRF5_SDK_14.2.0_17b948a/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/timer/: app_timer.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/button/: app_button.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/fifo/: app_fifo.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../nRF5_SDK_14.2.0_17b948a/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_default_backends.c nrf_log_backend_serial.c nrf_log_frontend.c nrf_log_str_formatter.c
    ../nRF5_SDK_14.2.0_17b948a/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/queue/: nrf_queue.c
    ../nRF5_SDK_14.2.0_17b948a/components/libraries/bsp/: bsp_nfc.c bsp.c
    ../nRF5_SDK_14.2.0_17b948a/components/drivers_nrf/i2s/: nrf_drv_i2s.c
  group System
    ../nRF5_SDK_14.2.0_17b948a/components/toolchain/: system_nrf52.c
    ../nRF5_SDK_14.2.0_17b948a/components/toolchain/arm/: arm_startup_nrf52.s
